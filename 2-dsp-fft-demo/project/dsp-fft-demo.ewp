# IAR project dsp-fft-demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F470xG GigaDevice GD32F470xG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F470; ARM_MATH_LOOPUNROLL
  ICCARM.CCIncludePath2: ..\..\common\Firmware\GD32F4xx_standard_peripheral\Include; ..\..\common\Firmware\CMSIS; ..\..\common\Firmware\CMSIS\GD\GD32F4xx\Include; ..\..\common\drive\LED; ..\include; ..\..\common\drive\USART; ..\..\common\3rdPary\CMSIS-DSP\Include; ..\..\common\3rdPary\lwrb
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: led-demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../source/: gd32f4xx_it.c main.c systick.c
  group CMSIS
    ../../common/Firmware/CMSIS/GD/GD32F4xx/Source/IAR/: startup_gd32f450_470.s
    ../../common/Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group CMSIS-DSP
    ../../common/3rdPary/CMSIS-DSP/Source/TransformFunctions/: TransformFunctions.c
  group Driver
    ../../common/drive/USART/: bsp_usart.c
    ../../common/drive/LED/: Led.c
  group Peripherals
    ../../common/Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
